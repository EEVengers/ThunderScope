File: Hardware/KiCad/Thunderscope_Rev5/CON_PCIe_X4.kicad_sch (KiCad schematic)
At the start: 5 parts, among them P1 PCIeX4-GF-2D-1000-1K-O64

Commit message: Linked PCB to Schematic

Commit message: Added WIP Mech Model and Interposer
Also reworked rev5 power tree
Other:
- note added: "TODO: 12V to VUSB Buck Regulator"
Changed lines of the file:
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@@
+		)
+	)
+	(text "TODO: 12V to VUSB Buck Regulator"
+		(exclude_from_sim no)
+		(at 106.68 175.26 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+				(color 255 0 0 1)
+			)
 		)
 	)
@@
 		)
 	)
-	(text_box "- Nominal values used, dimensions in mm\n- The mounting holes and keep-out areas around them are only required when the I/O bracket is mounted on the card directly\n- Component height rule and clearance rule derived from PCI_Express_CEM_r2.0.pdf, Page 84.\n- Stackup is not specified in PCI_Express_CEM_r2.0.pdf, nor implemented in this template."
-		(exclude_from_sim no)
-		(at 161.383 163.068 0)
-		(size 120.557 12.192)
-		(margins 0.9525 0.9525 0.9525 0.9525)
-		(stroke
-			(width -0.0001)
-			(type default)
-			(color 0 0 0 1)
-		)
-		(fill
-			(type color)
-			(color 255 255 255 1)
-		)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left top)
-		)
-	)

Commit message: Schematic WIP
Parts:
- added SHLD1: 9204, symbol Thunderscope_Rev5:PCIe IO Shield
- P1: footprint PCIeX4-GF-2D-1000-1K-O64 -> Thunderscope_Rev5:PCIeX4-GF-2D-1000-1K-O64; now left out of the parts list
- R41: value ${ALTIUM_VALUE} -> 0; footprint GEN_R_0402 -> Thunderscope_Rev5:GEN_R_0402; ALTIUM_VALUE 0 -> (none)
- R42: value ${ALTIUM_VALUE} -> 0.01; footprint GEN_R_0603 -> Thunderscope_Rev5:GEN_R_0603; ALTIUM_VALUE 0.01 -> (none)
- TP14, TP15: footprint KEY_5015 -> Thunderscope_Rev5:KEY_5015
Other:
- note added: "PCIe bracket"

Commit message: Schematic cleanup and RGB status LED
Connections:
- net +12V_PCIe: now also R42.1, TP14.1
- net +3V3_PCIe: no longer R42.1, TP14.1
- net +3V3_IN renamed +12V_IN
Changed lines of the file:
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@@
 			(font
 				(size 1.27 1.27)
+				(thickness 0.254)
+				(bold yes)
 				(color 255 0 0 1)
 			)
@@
 		)
 	)
-	(label "+3V3_PCIe"
+	(label "+12V_PCIe"
 		(at 71.12 165.1 0)
 		(effects
@@
 			)
 		)
-		(property "Value" "+3V3_IN"
+		(property "Value" "+12V_IN"
 			(at 129.54 158.75 0)
 			(effects

Commit message: Refactored Schematic
Parts:
- added C28, C29, C32, C33, C36, C37, C40, C41, C44, C45: 100nF, Thunderscope_Rev5:GEN_C_0201, symbol Thunderscope_Rev5:CAP 100nF 6.3V X5R 0201
- added D4, D5: TPD1E1B04, Thunderscope_Rev5:TI_X1SON_DPY0002A, symbol Thunderscope_Rev5:TVS TPD1E1B04
- added J3: 1.27mm 6 Pin TH, Thunderscope_Rev5:GEN_1.27mm_2x5_Pin_TH_RA, symbol Thunderscope_Rev5:CONN 1.27mm 2x5 Pin TH RA
- added R23: 49.9, Thunderscope_Rev5:GEN_R_0402, symbol Thunderscope_Rev5:RES 49.9 OHM 1% 1/10W 0402
- added R25, R26, R29, R30, R33, R34, R37, R38: 0, Thunderscope_Rev5:GEN_R_0201, symbol Thunderscope_Rev5:RES 0 OHM 1% 1/20W 0201
- added R3, R5: 0, Thunderscope_Rev5:GEN_R_0402, symbol Thunderscope_Rev5:RES 0 OHM 1/16W 0402
- added R71: 0.01, Thunderscope_Rev5:GEN_R_0603, symbol Thunderscope_Rev5:RES 0.01 OHM 1% 1/4W 0603
Connections:
- net GND: now also D4.2 (A), D5.2 (A), J3.1, J3.10, J3.2, J3.4, J3.5, J3.6, J3.8, J3.9
- net PCIe_PER0_N: now also C40.1
- net PCIe_PER0_P: now also C41.1
- net PCIe_PER1_N: now also C36.1
- net PCIe_PER1_P: now also C37.1
- net PCIe_PER2_N: now also C32.1
- net PCIe_PER2_P: now also C33.1
- net PCIe_PER3_N: now also C28.1
- net PCIe_PER3_P: now also C29.1
- net PCIe_PERST#: now also R23.2
- net PCIe_PET0_N: now also R37.2
- net PCIe_PET0_P: now also R38.2
- net PCIe_PET1_N: now also R33.2
- net PCIe_PET1_P: now also R34.2
- net PCIe_PET2_N: now also R29.2
- net PCIe_PET2_P: now also R30.2
- net PCIe_PET3_N: now also R25.2
- net PCIe_PET3_P: now also R26.2
- net PCIe_REFCLK_N: now also C44.1
- net PCIe_REFCLK_P: now also C45.1
- new net +5V2: R71.2
- new net +VUSB: R71.1
- new net MGT_CLK0_N: C44.2
- new net MGT_CLK0_P: C45.2
- new net MGT_RX0_N: R25.1
- new net MGT_RX0_P: R26.1
- new net MGT_RX1_N: R29.1
- new net MGT_RX1_P: R30.1
- new net MGT_RX2_N: R33.1
- new net MGT_RX2_P: R34.1
- new net MGT_RX3_N: R37.1
- new net MGT_RX3_P: R38.1
- new net MGT_TX0_N: C28.2
- new net MGT_TX0_P: C29.2
- new net MGT_TX1_N: C32.2
- new net MGT_TX1_P: C33.2
- new net MGT_TX2_N: C36.2
- new net MGT_TX2_P: C37.2
- new net MGT_TX3_N: C40.2
- new net MGT_TX3_P: C41.2
- new net PCIe_PERST#_R: R23.1
- new net REFINOUT: R5.1
- new net REFINOUT2: D4.1 (K), J3.3, R5.2
- new net SYNC: R3.1
- new net SYNC2: D5.1 (K), J3.7, R3.2
Other:
- note added: "AC Couple PER Lines with 100nF"
- note added: "AC Couple REFCLK Lines with 100nF"
- moved on the sheet: P1, R41, R42, SHLD1, TP14, TP15

Commit message: Schematic Rapidly Approaching Done
Still have to clear some new ERCs from the refactor
Parts:
- added C80, C83, C84: 22uF, Thunderscope_Rev5:GEN_C_0805, symbol Thunderscope_Rev5:CAP 22uF 25V X5R 0805
- added C81, C82: 100nF, Thunderscope_Rev5:GEN_C_0402, symbol Thunderscope_Rev5:CAP 100nF 16V X7R 0402
- added L6: 4.7uH, Thunderscope_Rev5:IND_SRN6045TA-100M, symbol Thunderscope_Rev5:IND 4.7uH 4.5A 26 MOHM 6x6mm
- added R73: 280K, Thunderscope_Rev5:GEN_R_0402, symbol Thunderscope_Rev5:RES 280K OHM 1% 1/16W 0402
- added R74: 35.7k, Thunderscope_Rev5:GEN_R_0402, symbol Thunderscope_Rev5:RES 35.7K OHM 1% 1/16W 0402
- added U11: TPS563203DRLR, Thunderscope_Rev5:TI_SOT563_DRL0006A, symbol Thunderscope_Rev5:IC BUCK TPS563203DRL
Connections:
- net +VUSB: now also C83.2, C84.2, L6.2, R73.2
- net GND: now also C80.1, C81.1, C83.1, C84.1, R74.2, U11.3 (GND)
- net +12V_IN: no longer names the net of R42.2, TP15.1
- net +12V_IN: now also C80.2, C81.2, U11.1 (VIN), U11.5 (EN)
- new net: C82.2, L6.1, U11.2 (SW)
- new net: C82.1, U11.4 (BST)
- new net: R73.1, R74.1, U11.6 (FB)
Other:
- note added: "5V2 Buck Converter"
- note added: "DONE: 12V to VUSB Buck Regulator"
- note added: "Refclock and Sync Header"
- note added: "Vout = 0.6 * (280/35.7 + 1)"
- note added: "Vout = 0.6 * (R1/R2 + 1)"
- note added: "Vout = 5.31V"
- note removed: "TODO: 12V to VUSB Buck Regulator"
- moved on the sheet: C28, C29, C32, C33, C36, C37, C40, C41, C44, C45, P1, R23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
