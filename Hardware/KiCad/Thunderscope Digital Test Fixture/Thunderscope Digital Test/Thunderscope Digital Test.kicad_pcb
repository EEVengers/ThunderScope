# Repository EEVengers/ThunderScope

File README.md:

# ThunderScope
Low-Cost Four Channel 1GSPS Oscilloscope using Thunderbolt/USB4 to stream data to PC for processing and display. 

Join our [discord](https://discord.com/invite/pds7k3WrpK), we are now at #thunderscope:matrix.org on matrix or #thunderscope:libera.chat on IRC as well!

All of our latest documentation is on our [docs site](https://docs.eevengers.com/ThunderScope/latest/index.html).

You can get the hardware through our [crowdsupply page](https://www.crowdsupply.com/eevengers/thunderscope)!

## KiCad design Hardware/KiCad/Thunderscope Digital Test Fixture/Thunderscope Digital Test/Thunderscope Digital Test.kicad_pcb

File Hardware/README.md:

All the hardware for this project is licensed under CERN-OHL-P-2.0

Parts:
C1, C2, C3, C4, C5, C6, C7, C9, C11, C14, C15, C16, C17, C20, C21, C22, C23, C24: 1uF; C_0402; Voltage Rated 25V; Tolerance ±10%; Part CL05A105KA5NQNC; LCSC C52923
C8: 100nF; C_0402; Voltage Rated 16V; Tolerance ±10%; Part CL05B104KO5NNNC; LCSC C1525
C10, C13: 20pF; C_0402; Voltage Rated 50V; Tolerance ±5%; Part 0402CG200J500NT; LCSC C1554
C12: 100pF; C_0402; Voltage Rated 50V; Tolerance ±5%; Part 0402CG101J500NT; LCSC C1546
C18, C19: 2.2uF; C_0402; Voltage Rated 6.3V; Tolerance ±20%; Part CL05A225MQ5NSNC; LCSC C12530
C26, C27, C28, C29: 10uF; C_0603; Voltage Rated 25V; Tolerance ±20%; Part CL10A106MA8NRNC; LCSC C96446
D1, D2: TPD1E1B04; TI_X1SON_DPY0002A; MANUFACTURER PART NUMBER TPD1E1B04DPYR
H1, H2, H3, H4, H5, H6: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J2: Conn_02x30_Odd_Even; PinHeader_2x30_P2.54mm_Vertical
J3: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Horizontal
J4: 1.27mm 6 Pin TH; GEN_1.27mm_2x5_Pin_TH_RA; MANUFACTURER PART NUMBER 3220-10-0200-00
J9: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_GCT_USB4110
L1: Choke_Wurth_WE-CNSW_744232090; L_CommonMode_Wurth_WE-CNSW-1206
L5: 1uH; GEN_L_1210; MANUFACTURER PART NUMBER SRP3212-1R0M
R1, R2: 5.1kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF5101TCE; LCSC C25905
R5, R6, R7, R9: 0Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF0000TCE; LCSC C17168
R8, R10: 0Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF0000TCE; LCSC C17168; not fitted
R14, R15, R16, R17: 0Ω; R_0603; Overload Voltage (Max) 75V; Tolerance ±1%; Part 0603WAF0000T5E; LCSC C21189
R19: 20kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2002TCE; LCSC C25765
R20, R39: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R36: 4.7kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF4701TCE; LCSC C25900
R55: 90.9k; R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-0790K9L
U2: JTAG-HS2-Header; PinHeader_1x06_P2.54mm_Horizontal
U3: STM32H743ZGT6; LQFP-144_20x20mm_P0.5mm
U4, U5, U6: SN74LV1T34DCK; SOT-353_SC-70-5
U8: TPS62A02; TI_SOT563_DRL0006A; MANUFACTURER PART NUMBER TPS62A02DRLR
U12: USBLC6-2P6; SOT-666
X1: X322512MSB4SI; CRYSTAL-SMD_4P-L3.2-W2.5-BL; Frequency Tolerance ±10ppm; Part X322512MSB4SI; LCSC C9002

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, C11.1, C12.1, C14.1, C15.1, C16.1, C17.1, C20.1, C22.1, C23.1, C24.1, C26.1, C27.1, J3.1 (VTref), L5.2, R55.1, U2.6 (VREF), U3.6 (VBAT), U3.17 (VDD), U3.30 (VDD), U3.33 (VDDA), U3.39 (VDD), U3.52 (VDD), U3.62 (VDD), U3.72 (VDD), U3.84 (VDD), U3.95 (VDD33_USB), U3.108 (VDD), U3.121 (VDD), U3.131 (VDD), U3.143 (PDR_ON), U3.144 (VDD), U4.5 (VCC), U5.5 (VCC), U6.5 (VCC)
+VUSB: C28.1, C29.1, J9.A4 (VBUS), J9.A9 (VBUS), J9.B4 (VBUS), J9.B9 (VBUS), R20.2, R36.1, U8.3 (VIN), U12.5 (VBUS)
/ACQ_EN_R: J2.3, U3.127 (PG12)
/ACQ_PG_R: J2.1, U3.126 (PG11)
/ADC_CSn_R: J2.5, U3.128 (PG13)
/ADC_SCLK_R: J2.9, U3.133 (SPI1_SCK)
/ADC_SDATA_R: J2.7, R7.2, R8.2
/ATTEN_1_R: J1.39, U3.66 (PE13)
/ATTEN_2_R: J1.23, U3.57 (PG1)
/ATTEN_3_R: J1.15, U3.53 (PF13)
/ATTEN_4_R: J1.3, U3.45 (PC5)
/CLK25_R: J2.29, U3.26 (PC0)
/COMP_R: J1.47, U3.68 (PE15)
/D+: L1.1, U12.6 (I/O1)
/D-: L1.4, U12.4 (I/O2)
/DC_CPL_1_R: J1.37, U3.65 (PE12)
/DC_CPL_2_R: J1.21, U3.56 (PG0)
/DC_CPL_3_R: J1.13, U3.50 (PF12)
/DC_CPL_4_R: J1.7, U3.47 (PB1)
/DONE_R: J2.39, U3.27 (PC1)
/FE_EN_R: J1.59, U3.90 (PG5)
/FE_PG_R: J1.57, U3.89 (PG4)
/FPGA_EN_R: J2.41, U3.28 (PC2_C)
/HWID0_R: J2.49, U3.36 (PA2)
/HWID1_R: J2.51, U3.37 (PA3)
/HWID2_R: J2.53, U3.40 (PA4)
/In_D+: J9.A6 (D+), J9.B6 (D+), U12.3 (I/O2)
/In_D-: J9.A7 (D-), J9.B7 (D-), U12.1 (I/O1)
/LED_B_R: J1.27, U3.59 (PE8)
/LED_G_R: J1.29, U3.60 (PE9)
/LED_R_R: J1.25, U3.58 (PE7)
/OSC_IN: C13.1, U3.23 (RCC_OSC_IN), X1.3 (OSC)
/OSC_OUT: C10.1, R6.1, X1.1 (OSC)
/PERST#_R: J2.47, U3.35 (PA1)
/PGA_CSn_1_R: J1.35, U3.64 (PE11)
/PGA_CSn_2_R: J1.19, U3.55 (PF15)
/PGA_CSn_3_R: J1.11, U3.49 (PF11)
/PGA_CSn_4_R: J1.9, U3.48 (PB2)
/PGA_SCLK_R: J1.45, U3.74 (SPI2_SCK)
/PGA_SDIO_R: J1.43, R9.2, R10.2
/PG_1V0_R: J2.57, U3.42 (PA6)
/PG_1V8_R: J2.59, U3.43 (PA7)
/PLL_RSTn_R: J2.11, U3.140 (PB9)
/PLL_SCL_R: J2.15, U3.136 (I2C1_SCL)
/PLL_SDA_R: J2.13, U3.137 (I2C1_SDA)
/QSPI_CLK_R: J2.19, U3.22 (QUADSPI_CLK)
/QSPI_CS_R: J2.27, U3.91 (QUADSPI_BK1_NCS)
/QSPI_DQ0_R: J2.21, U3.20 (QUADSPI_BK1_IO0)
/QSPI_DQ1_R: J2.25, U3.21 (QUADSPI_BK1_IO1)
/QSPI_DQ2_R: J2.23, U3.19 (QUADSPI_BK1_IO2)
/QSPI_DQ3_R: J2.17, U3.18 (QUADSPI_BK1_IO3)
/REFINOUT: D1.1 (K), J4.3, U3.110 (PA15)
/SYNC: D2.1 (K), J4.7, U3.111 (PC10)
/SYNC_DE_R: J2.45, U3.34 (PA0)
/SYNC_REn_R: J2.43, U3.29 (PC3_C)
/TCK_R: J2.31, U2.4 (TCK)
/TDI_R: J2.35, U2.2 (TDI)
/TDO_R: J2.33, U2.3 (TDO)
/TERM_1_R: J1.41, U3.67 (PE14)
/TERM_2_R: J1.33, U3.63 (PE10)
/TERM_3_R: J1.17, U3.54 (PF14)
/TERM_4_R: J1.5, U3.46 (PB0)
/TMS_R: J2.37, U2.1 (TMS)
/TRIM_SCL_5V_R: J1.55, U4.2 (A)
/TRIM_SCL_R: J1.51, R16.2
/TRIM_SDA_5V_R: J1.53, U5.2 (A)
/TRIM_SDA_R: J1.49, R17.2
/VARIANT_R: J2.55, U3.41 (PA5)
/VBUS_detect: C21.1, R36.2, R39.1, U3.101 (USB_OTG_FS_VBUS)
/VUSB_PG_3V3_R: U3.44 (PC4), U6.4 (Y)
/VUSB_PG_5V_R: J1.1, U6.2 (A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C26.2, C27.2, C28.2, C29.2, D1.2 (A), D2.2 (A), H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, J1.2, J1.4, J1.6, J1.8, J1.10, J1.12, J1.14, J1.16, J1.18, J1.20, J1.22, J1.24, J1.26, J1.28, J1.30, J1.32, J1.34, J1.36, J1.38, J1.40, J1.42, J1.44, J1.46, J1.48, J1.50, J1.52, J1.54, J1.56, J1.58, J1.60, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J2.22, J2.24, J2.26, J2.28, J2.30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
unnamed: C18.1, U3.106 (VCAP)
unnamed: C19.1, U3.71 (VCAP)
unnamed: J9.A5 (CC1), R2.1
unnamed: J9.B5 (CC2), R1.1
unnamed: R14.2, R16.1
unnamed: R15.2, R17.1
unnamed: R5.2, U3.138 (BOOT0)
unnamed: U3.100 (I2C3_SCL), U4.4 (Y)
unnamed: R7.1, U3.134 (SPI1_MISO)
unnamed: R8.1, U3.135 (SPI1_MOSI)
unnamed: R14.1, U3.69 (I2C2_SCL)
unnamed: R15.1, U3.70 (I2C2_SDA)
unnamed: R9.1, U3.75 (SPI2_MISO)
unnamed: R10.1, U3.76 (SPI2_MOSI)
unnamed: U3.99 (I2C3_SDA), U5.4 (Y)
unnamed: R6.2, U3.24 (RCC_OSC_OUT)
unnamed: R20.1, U8.4 (EN)
unnamed: C12.2, R19.1, R55.2, U8.5 (FB)
unnamed: L5.1, U8.2 (SW)
SWCLK: J3.4 (SWCLK/TCK), U3.109 (DEBUG_JTCK-SWCLK)
SWDIO: J3.2 (SWDIO/TMS), U3.105 (DEBUG_JTMS-SWDIO)
filtered_D+: L1.3, U3.104 (USB_OTG_FS_DP)
filtered_D-: L1.2, U3.103 (USB_OTG_FS_DM)
~RESET: C8.2, J3.10 (~RESET), U3.25 (NRST)

Notes on the sheet:
Decoupling
MCU
MCU SWD Debug
Uses JLC04161H-3313 stackup
Vout = 0.6 * (R1/R2 + 1)
Board Connectors
REFCLK and SYNC Connector
JTAG-HS2 Connector
USB
Vout = 3.327V
12MHz Crystal Oscillator
3.3V - 620mA
Mounting Holes
Vout = 0.6 * (90.9/20 + 1)

Board: 4 copper layers, 142.5 x 136.3 mm, 68 parts (57 on the bottom side), 96 nets.

File Hardware/KiCad/Thunderscope Digital Test Fixture/Thunderscope Digital Test/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C11, C14, C15, C16, C17, C2, C20, C21, C22, C23, C24, C3, C4, C5, C6, C7, C9",C_0402,18,1uF,C52923
"C10, C13",C_0402,2,20pF,C1554
C12,C_0402,1,100pF,C1546
"C18, C19",C_0402,2,2.2uF,C12530
"C26, C27, C28, C29",C_0603,4,10uF,C96446
C8,C_0402,1,100nF,C1525
"D1, D2",TI_X1SON_DPY0002A,2,TPD1E1B04,
"J1, J2",PinHeader_2x30_P2.54mm_Vertical,2,Conn_02x30_Odd_Even,
J3,PinHeader_2x05_P1.27mm_Horizontal,1,Conn_ARM_JTAG_SWD_10,
J4,GEN_1.27mm_2x5_Pin_TH_RA,1,1.27mm 6 Pin TH,
J9,USB_C_Receptacle_GCT_USB4110,1,USB_C_Receptacle_USB2.0_14P,
L1,L_CommonMode_Wurth_WE-CNSW-1206,1,Choke_Wurth_WE-CNSW_744232090,
L5,GEN_L_1210,1,1uH,
"R1, R2",R_0402,2,5.1kΩ,C25905
"R14, R15, R16, R17",R_0603,4,0Ω,C21189
R19,R_0402,1,20kΩ,C25765
"R20, R39",R_0402,2,10kΩ,C25744
R36,R_0402,1,4.7kΩ,C25900
"R5, R6, R7, R9",R_0402,4,0Ω,C17168
R55,R_0402,1,90.9k,
U12,SOT-666,1,USBLC6-2P6,
U2,PinHeader_1x06_P2.54mm_Horizontal,1,JTAG-HS2-Header,
U3,LQFP-144_20x20mm_P0.5mm,1,STM32H743ZGT6,
"U4, U5, U6",SOT-353_SC-70-5,3,SN74LV1T34DCK,
U8,TI_SOT563_DRL0006A,1,TPS62A02,
X1,CRYSTAL-SMD_4P-L3.2-W2.5-BL,1,X322512MSB4SI,C9002

## KiCad design Hardware/KiCad/Thunderscope_Rev5.1_Bed_Of_Nails_Adaptor/Thunderscope_Rev5.1_Bed_Of_Nails.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D94, D95, D96, D97, D98, D100, D101: D5V0X1B2LP-7B; X1-DFN1006-2; LCSC PN C500802
D93, D99: D12V0L1B2LP-7B; X1-DFN1006-2; LCSC PN C443636
H1, H2, H3, H4, H5, H6: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J2: Conn_02x30_Odd_Even; PinSocket_2x30_P2.54mm_Vertical
J3, J4: Conn_02x22_Odd_Even; PinSocket_2x22_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60: 33; R_0402_1005Metric; LCSC PN C25105
TP1, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP16, TP17, TP18, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP36, TP37, TP38, TP39, TP40, TP41, TP42, TP43, TP44, TP46, TP47, TP48, TP49, TP50, TP51, TP52, TP53, TP54, TP55, TP56, TP57, TP58, TP59, TP60, TP61, TP62, TP63, TP64, TP65, TP66, TP67, TP68, TP69, TP70, TP71, TP72, TP75, TP76, TP77, TP78, TP79, TP80, TP81, TP82, TP83, TP84, TP85, TP86, TP1014_1, TP1014_2, TP1014_3, TP1014_4, TP1015_1, TP1015_2, TP1015_3, TP1015_4, TP1016_1, TP1016_2, TP1016_3, TP1016_4, TP1017_1, TP1017_2, TP1017_3, TP1017_4, TP1018_1, TP1018_2, TP1018_3, TP1018_4: PCB; 0906415207514110
TP2, TP3, TP45, TP73, TP74: 5019; 0906415207514110; MANUFACTURER PART NUMBER 5019
TP14, TP15, TP19, TP20: 5015; 0906415207514110; MANUFACTURER PART NUMBER 5015

Connections:
/+1V0: D100.2 (A2), J3.9, TP66.1
/+1V0_R: D94.2 (A2), J3.11, TP65.1
/+1V2_MGT: D70.2 (A2), J3.25, TP50.1
/+1V8: D101.2 (A2), J3.29, TP64.1
/+1V8_ACQ: D63.2 (A2), J3.39, TP33.1
/+1V8_LDO: D84.2 (A2), J3.23, TP51.1
/+1V8_R: D95.2 (A2), J3.27, TP63.1
/+1V8_R_LDO: D79.2 (A2), J3.21, TP49.1
/+2V5: D68.2 (A2), J3.33, TP68.1
/+2V5_ACQ: D69.2 (A2), J3.35, TP36.1
/+2V5_R: D61.2 (A2), J3.31, TP67.1
/+2V5_R_ACQ: D62.2 (A2), J3.37, TP32.1
/+3V3: D83.2 (A2), J3.5, TP70.1
/+3V3_ACQ: D74.2 (A2), J3.15, TP27.1
/+3V3_PGA: D88.2 (A2), J4.13, TP39.1
/+3V3_R: D78.2 (A2), J3.7, TP69.1
/+5V: D89.2 (A2), J4.31, TP35.1
/+5V3: D91.2 (A2), J4.43, TP72.1
/+5V3_CP: D71.2 (A2), J4.29, TP41.1
/+5V3_LDO: D96.2 (A2), J4.35, TP37.1
/+5V3_R_CP: D64.2 (A2), J4.27, TP28.1
/+5V3_R_LDO: D90.2 (A2), J4.33, TP34.1
/+5V_PGA: D72.2 (A2), J4.11, TP40.1
/+5V_R_PGA: D65.2 (A2), J4.9, TP38.1
/+12V_PCIe: D99.2 (A2), J3.41, TP14.1
/+12V_PCIe_R: D93.2 (A2), J3.43, TP15.1
/+VBIAS: D92.2 (A2), J4.19, TP8.1
/+VUSB: D87.2 (A2), J4.39, TP21.1
/+VUSB_5V3: D97.2 (A2), J4.41, TP71.1
/+VUSB_ACQ: D85.2 (A2), J3.19, TP30.1
/+VUSB_M2: D67.2 (A2), J3.1, TP19.1
/+VUSB_M2_R: D60.2 (A2), J3.3, TP20.1
/+VUSB_R: D82.2 (A2), J4.37, TP22.1
/+VUSB_R_ACQ: D80.2 (A2), J3.17, TP26.1
/-5V: D86.2 (A2), J4.21, TP31.1
/-5V_R: D81.2 (A2), J4.23, TP29.1
/-VBIAS: D98.2 (A2), J4.25, TP9.1
/ACQ_EN: D11.2 (A2), R59.1, TP1.1
/ACQ_EN_R: J2.3, R59.2
/ACQ_PG: D5.2 (A2), R60.1, TP24.1
/ACQ_PG_R: J2.1, R60.2
/ADC_CSn: D30.2 (A2), R56.1, TP10.1
/ADC_CSn_R: J2.5, R56.2
/ADC_SCLK: D32.2 (A2), R55.1, TP12.1
/ADC_SCLK_R: J2.9, R55.2
/ADC_SDATA: D38.2 (A2), R54.1, TP11.1
/ADC_SDATA_R: J2.7, R54.2
/ATTEN_1: D50.2 (A2), R5.1, TP1015_1.1
/ATTEN_1_R: J1.39, R5.2
/ATTEN_2: D45.2 (A2), R6.1, TP1015_2.1
/ATTEN_2_R: J1.23, R6.2
/ATTEN_3: D39.2 (A2), R7.1, TP1015_3.1
/ATTEN_3_R: J1.15, R7.2
/ATTEN_4: D33.2 (A2), R8.1, TP1015_4.1
/ATTEN_4_R: J1.3, R8.2
/CLK25: D58.2 (A2), R45.1, TP62.1
/CLK25_R: J2.29, R45.2
/COMP: D34.2 (A2), R16.1, TP61.1
/COMP_R: J1.47, R16.2
/DC_CPL_1: D20.2 (A2), R9.1, TP1018_1.1
/DC_CPL_1_R: J1.37, R9.2
/DC_CPL_2: D14.2 (A2), R10.1, TP1018_2.1
/DC_CPL_2_R: J1.21, R10.2
/DC_CPL_3: D8.2 (A2), R11.1, TP1018_3.1
/DC_CPL_3_R: J1.13, R11.2
/DC_CPL_4: D2.2 (A2), R12.1, TP1018_4.1
/DC_CPL_4_R: J1.7, R12.2
/DONE: D42.2 (A2), R49.1, TP44.1
/DONE_R: J2.39, R49.2
/FE_EN: D59.2 (A2), R23.1, TP4.1
/FE_EN_R: J1.59, R23.2
/FE_PG: D57.2 (A2), R24.1, TP23.1
/FE_PG_R: J1.57, R24.2
/FPGA_EN: D48.2 (A2), R48.1, TP81.1
/FPGA_EN_R: J2.41, R48.2
/HWID0: D24.2 (A2), R35.1, TP85.1
/HWID0_R: J2.49, R35.2
/HWID1: D18.2 (A2), R36.1, TP84.1
/HWID1_R: J2.51, R36.2
/HWID2: D12.2 (A2), R37.1, TP83.1
/HWID2_R: J2.53, R37.2
/LED_B: D40.2 (A2), R15.1, TP58.1
/LED_B_R: J1.27, R15.2
/LED_G: D46.2 (A2), R14.1, TP57.1
/LED_G_R: J1.29, R14.2
/LED_R: D51.2 (A2), R13.1, TP56.1
/LED_R_R: J1.25, R13.2
/PERST#: D36.2 (A2), R50.1, TP13.1
/PERST#_R: J2.47, R50.2
/PGA_BIAS_1: D77.2 (A2), J4.7, TP1017_1.1
/PGA_BIAS_2: D75.2 (A2), J4.5, TP1017_2.1
/PGA_BIAS_3: D73.2 (A2), J4.3, TP1017_3.1
/PGA_BIAS_4: D66.2 (A2), J4.1, TP1017_4.1
/PGA_CSn_1: D21.2 (A2), R19.1, TP1016_1.1
/PGA_CSn_1_R: J1.35, R19.2
/PGA_CSn_2: D15.2 (A2), R20.1, TP1016_2.1
/PGA_CSn_2_R: J1.19, R20.2
/PGA_CSn_3: D9.2 (A2), R21.1, TP1016_3.1
/PGA_CSn_3_R: J1.11, R21.2
/PGA_CSn_4: D3.2 (A2), R22.1, TP1016_4.1
/PGA_CSn_4_R: J1.9, R22.2
/PGA_SCLK: D27.2 (A2), R17.1, TP25.1
/PGA_SCLK_R: J1.45, R17.2
/PGA_SDIO: D25.2 (A2), R18.1, TP42.1
/PGA_SDIO_R: J1.43, R18.2
/PG_1V0: D23.2 (A2), R57.1, TP79.1
/PG_1V0_R: J2.57, R57.2
/PG_1V8: D17.2 (A2), R58.1, TP80.1
/PG_1V8_R: J2.59, R58.2
/PLL_RSTn: D44.2 (A2), R53.1, TP18.1
/PLL_RSTn_R: J2.11, R53.2
/PLL_SCL: D54.2 (A2), R51.1, TP17.1
/PLL_SCL_R: J2.15, R51.2
/PLL_SDA: D49.2 (A2), R52.1, TP16.1
/PLL_SDA_R: J2.13, R52.2
/QSPI_CLK: D28.2 (A2), R39.1, TP43.1
/QSPI_CLK_R: J2.19, R39.2
/QSPI_CS: D4.2 (A2), R44.1, TP53.1
/QSPI_CS_R: J2.27, R44.2
/QSPI_DQ0: D26.2 (A2), R40.1, TP47.1
/QSPI_DQ0_R: J2.21, R40.2
/QSPI_DQ1: D22.2 (A2), R41.1, TP46.1
/QSPI_DQ1_R: J2.25, R41.2
/QSPI_DQ2: D16.2 (A2), R42.1, TP48.1
/QSPI_DQ2_R: J2.23, R42.2
/QSPI_DQ3: D10.2 (A2), R43.1, TP52.1
/QSPI_DQ3_R: J2.17, R43.2
/SYNC_DE: D53.2 (A2), R47.1, TP54.1
/SYNC_DE_R: J2.45, R47.2
/SYNC_REn: D56.2 (A2), R46.1, TP55.1
/SYNC_REn_R: J2.43, R46.2
/TCK: D43.2 (A2), R31.1, TP77.1
/TCK_R: J2.31, R31.2
/TDI: D31.2 (A2), R33.1, TP75.1
/TDI_R: J2.35, R33.2
/TDO: D37.2 (A2), R32.1, TP76.1
/TDO_R: J2.33, R32.2
/TERM_1: D19.2 (A2), R1.1, TP1014_1.1
/TERM_1_R: J1.41, R1.2
/TERM_2: D13.2 (A2), R2.1, TP1014_2.1
/TERM_2_R: J1.33, R2.2
/TERM_3: D7.2 (A2), R3.1, TP1014_3.1
/TERM_3_R: J1.17, R3.2
/TERM_4: D1.2 (A2), R4.1, TP1014_4.1
/TERM_4_R: J1.5, R4.2
/TMS: D29.2 (A2), R34.1, TP78.1
/TMS_R: J2.37, R34.2
/TRIM_SCL: D55.2 (A2), R25.1, TP59.1
/TRIM_SCL_5V: D41.2 (A2), R28.1, TP6.1
/TRIM_SCL_5V_R: J1.55, R28.2
/TRIM_SCL_R: J1.51, R25.2
/TRIM_SDA: D52.2 (A2), R26.1, TP60.1
/TRIM_SDA_5V: D47.2 (A2), R27.1, TP7.1
/TRIM_SDA_5V_R: J1.53, R27.2
/TRIM_SDA_R: J1.49, R26.2
/VARIANT: D6.2 (A2), R38.1, TP82.1
/VARIANT_R: J2.55, R38.2
/VCM: D76.2 (A2), J3.13, TP5.1
/VUSB_PG_5V: D35.2 (A2), R29.1, TP86.1
/VUSB_PG_5V_R: J1.1, R29.2
GND: D1.1 (A1), D2.1 (A1), D3.1 (A1), D4.1 (A1), D5.1 (A1), D6.1 (A1), D7.1 (A1), D8.1 (A1), D9.1 (A1), D10.1 (A1), D11.1 (A1), D12.1 (A1), D13.1 (A1), D14.1 (A1), D15.1 (A1), D16.1 (A1), D17.1 (A1), D18.1 (A1), D19.1 (A1), D20.1 (A1), D21.1 (A1), D22.1 (A1), D23.1 (A1), D24.1 (A1), D25.1 (A1), D26.1 (A1), D27.1 (A1), D28.1 (A1), D29.1 (A1), D30.1 (A1), D31.1 (A1), D32.1 (A1), D33.1 (A1), D34.1 (A1), D35.1 (A1), D36.1 (A1), D37.1 (A1), D38.1 (A1), D39.1 (A1), D40.1 (A1), D41.1 (A1), D42.1 (A1), D43.1 (A1), D44.1 (A1), D45.1 (A1), D46.1 (A1), D47.1 (A1), D48.1 (A1), D49.1 (A1), D50.1 (A1), D51.1 (A1), D52.1 (A1), D53.1 (A1), D54.1 (A1), D55.1 (A1), D56.1 (A1), D57.1 (A1), D58.1 (A1), D59.1 (A1), D60.1 (A1), D61.1 (A1), D62.1 (A1), D63.1 (A1), D64.1 (A1), D65.1 (A1), D66.1 (A1), D67.1 (A1), D68.1 (A1), D69.1 (A1), D70.1 (A1), D71.1 (A1), D72.1 (A1), D73.1 (A1), D74.1 (A1), D75.1 (A1), D76.1 (A1), D77.1 (A1), D78.1 (A1), D79.1 (A1), D80.1 (A1)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

Notes on the sheet:
Pogo pin PN is 0906-4-15-20-75-14-11-0
GNDs

Board: 4 copper layers, 142.5 x 123.5 mm, 276 parts (164 on the bottom side), 161 nets.

File Hardware/KiCad/Thunderscope_Rev5.1_Bed_Of_Nails_Adaptor/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"D1, D10, D100, D101, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D4, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D5, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D6, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D7, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D8, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D9, D90, D91, D92, D94, D95, D96, D97, D98",X1-DFN1006-2,99,D5V0X1B2LP-7B,C500802
"D93, D99",X1-DFN1006-2,2,D12V0L1B2LP-7B,C443636
"J1, J2",PinSocket_2x30_P2.54mm_Vertical,2,Conn_02x30_Odd_Even,
"J3, J4",PinSocket_2x22_P2.54mm_Vertical,2,Conn_02x22_Odd_Even,
"R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R2, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R3, R31, R32, R33, R34, R35, R36, R37, R38, R39, R4, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R5, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R6, R60, R7, R8, R9",0402,59,33,C25105
"TP14, TP15, TP19, TP20",0906415207514110,4,5015,
"TP2, TP3, TP45, TP73, TP74",0906415207514110,5,5019,
