# Repository EEVengers/ThunderScope (continued)

## KiCad design Hardware/KiCad/Interposer_Board_JoneyTech/Interposer_Board_JoneyTech.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_Pad_Via
J1, J2: M.2 Key M; PCB EDGE M.2 Key M

Connections:
+3V3: J1.2, J1.4, J1.12, J1.14, J1.16, J1.18, J1.70, J1.72, J1.74, J2.3, J2.5, J2.13, J2.15, J2.17, J2.19, J2.69, J2.71, J2.73
/PERST#: J1.50, J2.49
/REFCLK_N: J1.53, J2.54
/REFCLK_P: J1.55, J2.56
/RX0_N: J1.47, J2.48
/RX0_P: J1.49, J2.50
/RX1_N: J1.35, J2.36
/RX1_P: J1.37, J2.38
/RX2_N: J1.23, J2.24
/RX2_P: J1.25, J2.26
/RX3_N: J1.11, J2.12
/RX3_P: J1.13, J2.14
/TX0_N: J1.41, J2.42
/TX0_P: J1.43, J2.44
/TX1_N: J1.29, J2.30
/TX1_P: J1.31, J2.32
/TX2_N: J1.17, J2.18
/TX2_P: J1.19, J2.20
/TX3_N: J1.5, J2.6
/TX3_P: J1.7, J2.8
GND: H1.1, H2.1, H3.1, H4.1, J1.1, J1.3, J1.9, J1.15, J1.21, J1.27, J1.33, J1.39, J1.45, J1.51, J1.52, J1.57, J1.71, J1.73, J1.75, J2.2, J2.4, J2.10, J2.16, J2.22, J2.28, J2.34, J2.40, J2.46, J2.52, J2.58, J2.70, J2.72, J2.74

Notes on the sheet:
M.2 Key M
CLKREQ#
Main Board
Thunderbolt Board
Custom Pinout

Board: 4 copper layers, 122.5 x 99.5 mm, 7 parts (1 on the bottom side), 21 nets.

Other parts of the board:
HS1: HSB30-373710; SSKY_HSB30-373710_MountingHoles

## KiCad design Hardware/KiCad/Thunderscope_Rev5_Mech_Model/Thunderscope_Rev5_Mech_Model.kicad_pcb

Parts:
D1: RGB; LED_Kingbright_APFA3010_3x1.5mm_Horizontal; MANUFACTURER PART NUMBER APFA3010LSEKJ3ZGKQBC
J1, J2, J1002A1, J1002B1, J1002C1, J1002D1: BNC; MOL_0731000105; MANUFACTURER PART NUMBER 73100-0105
J3: 1.27mm 6 Pin TH; GEN_1.27mm_2x5_Pin_TH_RA; MANUFACTURER PART NUMBER 3220-10-0200-00
J4: TSW-101-16-G-Q-RA; GEN_5.08mm_1x2_Pin_TH_RA; MANUFACTURER PART NUMBER TSW-101-16-G-Q-RA
J5: 2.54mm 6 Pin TH; GEN_2.54MM_6_PIN_TH_RA; MANUFACTURER PART NUMBER 61300611021
J6: F300-1B7H1-11036-E100; AMPHENOL_F300-1B7H1-11036-E100; MANUFACTURER PART NUMBER F300-1B7H1-11036-E100
J7: 7792; KEY_7792; MANUFACTURER PART NUMBER 7792
J8: M.2 Key M; TE_M2_KEYM_2199230; MANUFACTURER PART NUMBER 1-2199230-5
J10, J11, J12: 009155002852006; KYO_009155002852006; MANUFACTURER PART NUMBER 009155002852006
P1: PCIeX4-GF-2D-1000-1K-O64
R1, R2, R3: 1K; GEN_R_0402; TOLERANCE 1%; MANUFACTURER PART NUMBER RC0402FR-071KL
SO1, SO2, SO3: 2.5mm M2 SMT Standoff; M2_SMT_Standoff_9774025243R; MANUFACTURER PART NUMBER 9774025243R

Connections:
+VUSB: J5.1, J8.3, J8.5, J8.13, J8.15, J8.17, J8.19, J8.69, J8.71, J8.73, J10.1
/LED_B: J5.4, R1.1
/LED_G: J5.5, R2.1
/LED_R: J5.3, R3.1
/M2_PER0_N: J8.42
/M2_PER0_P: J8.44
/M2_PER1_N: J8.30
/M2_PER1_P: J8.32
/M2_PER2_N: J8.18
/M2_PER2_P: J8.20
/M2_PER3_N: J8.6
/M2_PER3_P: J8.8
/M2_PERST#: J8.49
/M2_PET0_N: J8.48
/M2_PET0_P: J8.50
/M2_PET1_N: J8.36
/M2_PET1_P: J8.38
/M2_PET2_N: J8.24
/M2_PET2_P: J8.26
/M2_PET3_N: J8.12
/M2_PET3_P: J8.14
/M2_REFCLK_N: J8.54
/M2_REFCLK_P: J8.56
GND: D1.2 (A), J1.2 (SHIELD), J2.2 (SHIELD), J4.1, J5.6, J6.SH1, J6.SH2, J7.1, J8.2, J8.4, J8.10, J8.16, J8.22, J8.28, J8.34, J8.40, J8.46, J8.52, J8.58, J8.70, J8.72, J8.74, J8.76, J8.77, J10.2, J11.2, J12.1, J12.2, J1002A1.2 (SHIELD), J1002B1.2 (SHIELD), J1002C1.2 (SHIELD), J1002D1.2 (SHIELD), SO1.1, SO2.1, SO3.1
unnamed: D1.4 (B), R1.2
unnamed: D1.3 (G), R2.2
unnamed: D1.1 (R), R3.2

Notes on the sheet:
Main Board
Custom Pinout

Board: 2 copper layers, 122.5 x 103.6 mm, 23 parts (5 on the bottom side), 8 nets.

## KiCad design Hardware/KiCad/TS_Back_Endcap/TS_Back_Endcap.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; Mounting_Hole_#6
H5: MountingHole_Pad; 7792_PCB_Pads
TP1: 009155002852006_PCB_Pads
TP2, TP3: TestPoint; TestPoint_Pad_1.0x1.0mm

Connections:
/VUSB: TP1.2, TP2.1
GND: H1.1, H2.1, H3.1, H4.1, H5.1, TP1.1, TP3.1

Board: 2 copper layers, 103.0 x 30.5 mm, 8 parts (3 on the bottom side), 2 nets.

## KiCad design Hardware/KiCad/HMCAD1520_Impedence_Checker/HMCAD1520_Impedence_Checker.kicad_pcb

Parts:
D1, D2, D3: D_Filled; D_SOD-323
D4, D5, D6, D7, D8: ESD9B5.0ST5G; D_SOD-923
J1, J4: Conn_01x01; CT3151
K1, K2, K3: EE2-5NU; Relay_DPDT_Kemet_EE2_NU
Q1, Q2, Q3: DMN61D8LQ; SOT-23
R1, R2, R3, R4, R5, R6: 10k; R_0402_1005Metric
U1: HMCAD1520; 3M_248-5205-01
U2: Pico; RPi_Pico_SMD_TH

Connections:
+5V: D1.1 (K), D2.1 (K), D3.1 (K), K1.1, K2.1, K3.1, U2.39 (VSYS), U2.40 (VBUS)
/AVDD: D5.2 (A2), K1.10, U1.1 (AVDD), U1.36 (AVDD)
/AVDD2: D6.2 (A2), K1.8, U1.32 (AVDD2)
/DVDD: D8.2 (A2), K2.10, U1.7 (DVDD), U1.30 (DVDD)
/OVDD: D7.2 (A2), K2.8, U1.33 (OVDD)
/SEL0: R5.2, R6.1, U2.22 (GPIO17)
/SEL1: R3.2, R4.1, U2.21 (GPIO16)
/SEL2: R1.1, R2.2, U2.20 (GPIO15)
GND: D4.1 (A1), D5.1 (A1), D6.1 (A1), D7.1 (A1), D8.1 (A1), J4.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), R2.1, R3.1, R5.1, U1.8 (DVSS), U1.29 (DVSS), U1.31 (AVSS2), U1.39 (AVSS), U1.42 (AVSS), U1.45 (AVSS), U1.49 (EPAD), U2.3 (GND), U2.8 (GND), U2.13 (GND), U2.18 (GND), U2.23 (GND), U2.28 (GND), U2.38 (GND), U2.42 (GND)
unnamed: D1.2 (A), K1.12, Q2.3 (D)
unnamed: D2.2 (A), K2.12, Q1.3 (D)
unnamed: D3.2 (A), K3.12, Q3.3 (D)
unnamed: D4.2 (A2), J1.1, K3.9
unnamed: K1.9, K3.10
unnamed: K2.9, K3.8
unnamed: Q1.1 (G), R4.2
unnamed: Q2.1 (G), R1.2
unnamed: Q3.1 (G), R6.2

Board: 2 copper layers, 59.0 x 80.0 mm, 24 parts (5 on the bottom side), 18 nets.

## KiCad design Hardware/ADC/ADC.kicad_pcb

Parts:
C1, C4, C7, C10, C12, C16, C19, C21, C25: 1uF; C_0402
C2, C5, C8, C9, C11, C20, C22, C24: 10nF; C_0402
C3, C6, C23: 1nF; C_0402
C13, C15, C17: 10uF; C_0603
C14: 22pF; C_0402
C18: 0.1uF; C_0402
C26, C27, C28, C29: 33pF; C_0201_NoSilk
J1: FX18-40P-0.8SH
J2: FX18-80P-0.8SH
J5, J6: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
L1, L3: 1uH; L_0603
L2: 2.2uH; L_1008
MH1, MH2, MH3, MH4: Mounting Hole; MountingHole_2.7mm_M2.5_ISO14580_Pad
R1, R6, R7, R8: 10k; R_0402
R2: 820k; R_0402
R3: 220k; R_0402
R4: 182k; R_0402
R5: 499k; R_0402
R9, R10, R11, R12, R13, R14, R15, R18: 43; R_0201_NoSilk
U1: TPS62290; TI-DRV6
U2: MIC5319-ADJ; 6-MLF
U3: HMCAD1511; AD-LP7

Connections:
+1V8: C9.1, C10.1, C11.1, C12.1, C19.1, C20.1, L3.2, U3.7 (DVDD), U3.30 (DVDD)
+1V8A: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C21.1, C22.1, C23.1, L1.2, U3.1 (AVDD), U3.32 (AVDD2), U3.36 (AVDD); also elsewhere on the board
+3V3: C14.1, C15.1, C16.1, C24.1, C25.1, L2.2, R2.1, R6.1, R7.1, U2.1 (EN), U2.3 (VIN), U3.33 (OVDD)
+5VD: C13.1, J1.35, J1.36, J2.52, J2.55, J2.58, J2.61, J2.64, J2.67, J2.70, J2.73, J2.76, J6.1, R1.2, U1.4 (EN), U1.5 (VIN)
/ADC_PD: J2.34, R6.2, U3.6 (PD)
/ADC_PLL_SCLK: J2.36, J5.1, U3.4 (SCLK)
/ADC_PLL_SDIO: J2.37, J5.2, U3.3 (SDATA)
/ADJ: R3.2, R5.1, U2.5 (ADJ)
/BYP: C18.1, U2.6 (BYP)
/CLK+: U3.35 (CLK+); also elsewhere on the board
/CLK-: U3.34 (CLK-); also elsewhere on the board
/D1A+: J2.31, U3.9 (D1A+)
/D1A-: J2.30, U3.10 (D1A-)
/D1B+: J2.28, U3.11 (D1B+)
/D1B-: J2.27, U3.12 (D1B-)
/D2A+: J2.25, U3.13 (D2A+)
/D2A-: J2.24, U3.14 (D2A-)
/D2B+: J2.22, U3.15 (D2B+)
/D2B-: J2.21, U3.16 (D2B-)
/D3A+: J2.13, U3.21 (D3A+)
/D3A-: J2.12, U3.22 (D3A-)
/D3B+: J2.10, U3.23 (D3B+)
/D3B-: J2.9, U3.24 (D3B-)
/D4A+: J2.7, U3.25 (D4A+)
/D4A-: J2.6, U3.26 (D4A-)
/D4B+: J2.4, U3.27 (D4B+)
/D4B-: J2.3, U3.28 (D4B-)
/FB: C14.2, R2.2, R4.1, U1.3 (FB)
/FCLK+: J2.16, U3.19 (FCLK+)
/FCLK-: J2.15, U3.20 (FCLK-)
/FE_SCL: J1.1, J2.47
/FE_SCLK: J1.4, J2.39
/FE_SDA: J1.2, J2.48
/FE_SDIO: J1.3, J2.40
/IN1+: C26.1, R9.1, U3.47 (IN1+)
/IN1-: C26.2, R10.1, U3.46 (IN1-)
/IN2+: C27.1, R11.1, U3.44 (IN2+)
/IN2-: C27.2, R12.1, U3.43 (IN2-)
/IN3+: C28.1, R13.1, U3.41 (IN3+)
/IN3-: C28.2, R14.1, U3.40 (IN3-)
/IN4+: C29.1, R15.1, U3.38 (IN4+)
/IN4-: C29.2, R18.1, U3.37 (IN4-)
/LCLK+: J2.19, U3.17 (LCLK+)
/LCLK-: J2.18, U3.18 (LCLK-)
/MODE: R1.1, U1.2 (Mode)
/PGA_OUT_1+: J1.9, R9.2
/PGA_OUT_1-: J1.10, R10.2
/PGA_OUT_2+: J1.12, R11.2
/PGA_OUT_2-: J1.13, R12.2
/PGA_OUT_3+: J1.15, R13.2
/PGA_OUT_3-: J1.16, R14.2
/PGA_OUT_4+: J1.18, R15.2
/PGA_OUT_4-: J1.19, R18.2
/SW: L2.1, U1.1 (SW)
/VCM: J1.7, U3.48 (VCM)
/VOUT: C17.1, L1.1, L3.1, R3.1, U2.4 (VOUT)
/~ADC_CS: J2.38, R8.1, U3.2 (~CS)
/~ADC_RST: J2.35, R7.2, U3.5 (~RST)
/~PGA_CS_1: J1.40, J2.43
/~PGA_CS_2: J1.39, J2.44
/~PGA_CS_3: J1.38, J2.45
/~PGA_CS_4: J1.37, J2.46
/~PLL_LE: J2.49, J6.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, J1.5, J1.6, J1.8, J1.11, J1.14, J1.17, J1.20, J1.21, J1.22, J1.23, J1.24, J1.25, J1.26, J1.27, J1.28, J1.29, J1.30, J1.31, J1.32, J1.33, J1.34, J1.SHLD, J2.1, J2.2, J2.5, J2.8, J2.11, J2.14, J2.17, J2.20, J2.23, J2.26, J2.29, J2.32, J2.33, J2.41, J2.42, J2.50, J2.51, J2.53, J2.54, J2.56, J2.57, J2.59, J2.60, J2.62, J2.63, J2.65, J2.66, J2.68, J2.69, J2.71, J2.72, J2.74, J2.75, J2.77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; also elsewhere on the board

Notes on the sheet:
Star Point
