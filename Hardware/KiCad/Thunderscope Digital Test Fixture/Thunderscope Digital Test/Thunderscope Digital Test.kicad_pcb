# Repository EEVengers/ThunderScope (continued)

## KiCad design Hardware/ADC/ADC.kicad_pcb (continued)

Parts:
C30, C33: 1nF; C_0402
C31: 220pF; C_0402
C32: 0.1uF; C_0402
D1, D2: D_Schottky_x2_Serial_AKC; SOT323
J3, J4: UMC; A-1JB
J7: SMA; SMA-J-P-H-ST-EM1
R16, R22: 0; R_0402
R17, R20: 50; R_0402
R19, R21: 1k; R_0402
XFMR1: TC1-1-13MX+; MiniCircuits_AT1521

Connections:
+1V8A: D1.2 (K), D2.2 (K), R19.1; also elsewhere on the board
/CLK+: J3.1 (In), R16.1, R17.1; also elsewhere on the board
/CLK-: J4.1 (In), R20.2, R22.1; also elsewhere on the board
/Clocking/CLK_VCM: C31.1, C32.1, R17.2, R19.2, R20.1, R21.1
/Clocking/EXT_CLK: J7.1 (In), XFMR1.6
/Clocking/EXT_CLK+: C30.2, XFMR1.1
/Clocking/EXT_CLK-: C33.2, XFMR1.3
/Clocking/EXT_CLK_C+: C30.1, D1.3 (common), R16.2
/Clocking/EXT_CLK_C-: C33.1, D2.3 (common), R22.2
GND: C31.2, C32.2, D1.1 (A), D2.1 (A), J3.2 (Ext), J4.2 (Ext), J7.2 (Ext), R21.2, XFMR1.4; also elsewhere on the board

Notes on the sheet:
Depopulate 0 ohm jumpers when using external differential clock
Place jumpers close to UMC connectors to reduce stubbing

Board: 4 copper layers, 63.0 x 50.0 mm, 75 parts (5 on the bottom side), 70 nets.

## KiCad design Hardware/FE/FE Adaptor/FE_Adaptor.kicad_pcb

Board: 4 copper layers, 172.7 x 25.4 mm, 45 parts (0 on the bottom side), 62 nets.

Parts:
C1: 0.1uF; C_0402
C2, C7, C8, C9: 1uF; C_0402
C3, C5, C6, C10, C11: 10uF; C_0603
C4: 680pF; C_0402
D1: D_Schottky; SOD-123H
J1, J3, J4, J5, J7: FX18-40P-0.8SH
J2: Digital Debug; Pin_Header_Straight_2x05_Pitch2.54mm
J6, J8: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
L1: 2.2uH; WE-LQS
MH1, MH2, MH3, MH4: Mounting Hole; MountingHole_2.7mm_M2.5_ISO14580_Pad
R1, R2, R3, R5: 10k; R_0402
R4: 33.2k; R_0402
R6, R7, R12, R13: 3k; R_0402
R8, R10, R14, R16: 100; R_0402
R9, R11, R15, R17: 1k; R_0402
U1: TCA6424; TI-RGJ
U2: LMR62421; 6-WSON
U3: LP2980; SOT-23-5

Connections:
+3V3: C1.1, C11.1, R1.1, R2.1, R3.1, U1.27, U1.31, U3.5
+5V5: J3.32, J4.32, J5.32, J6.2, J7.32
+5VD: C10.1, J1.25, J1.26, J2.1, J3.34, J4.34, J5.34, J7.34, J8.2, U3.1, U3.3
/FE Inputs/-20dB_EN_1: J7.37, U1.17
/FE Inputs/-20dB_EN_2: J5.37, U1.12
/FE Inputs/-20dB_EN_3: J4.37, U1.7
/FE Inputs/-20dB_EN_4: J3.37, U1.2
/FE Inputs/-40dB_EN_1: J7.38, U1.18
/FE Inputs/-40dB_EN_2: J5.38, U1.13
/FE Inputs/-40dB_EN_3: J4.38, U1.8
/FE Inputs/-40dB_EN_4: J3.38, U1.3
/FE Inputs/CHANNEL_EN_1: J7.36, U1.16
/FE Inputs/CHANNEL_EN_2: J5.36, U1.11
/FE Inputs/CHANNEL_EN_3: J4.36, U1.6
/FE Inputs/CHANNEL_EN_4: J3.36, U1.1
/FE Inputs/DC_CPL_EN_1: J7.40, U1.20
/FE Inputs/DC_CPL_EN_2: J5.40, U1.15
/FE Inputs/DC_CPL_EN_3: J4.40, U1.10
/FE Inputs/DC_CPL_EN_4: J3.40, U1.5
/FE Inputs/PGA_OUT_1+: J1.12, J7.14
/FE Inputs/PGA_OUT_1-: J1.11, J7.13
/FE Inputs/PGA_OUT_2+: J1.9, J5.14
/FE Inputs/PGA_OUT_2-: J1.8, J5.13
/FE Inputs/PGA_OUT_3+: J1.6, J4.14
/FE Inputs/PGA_OUT_3-: J1.5, J4.13
/FE Inputs/PGA_OUT_4+: J1.3, J3.14
/FE Inputs/PGA_OUT_4-: J1.2, J3.13
/FE Inputs/PGA_VCM: J1.14, J3.11, J4.11, J5.11, J7.11
/FE Inputs/TERM_EN_1: J7.39, U1.19
/FE Inputs/TERM_EN_2: J5.39, U1.14
/FE Inputs/TERM_EN_3: J4.39, U1.9
/FE Inputs/TERM_EN_4: J3.39, U1.4
/FE Inputs/VBIAS1: J7.25, R6.1
/FE Inputs/VBIAS2: J5.25, R7.1
/FE Inputs/VBIAS3: J4.25, R12.1
/FE Inputs/VBIAS4: J3.25, R13.1
/FE Inputs/~PGA_CS_1: J1.21, J2.8, J7.3
/FE Inputs/~PGA_CS_2: J1.22, J2.6, J5.3
/FE Inputs/~PGA_CS_3: J1.23, J2.4, J4.3
/FE Inputs/~PGA_CS_4: J1.24, J2.2, J3.3
/FE_SCL: J1.20, J2.9, J3.1, J4.1, J5.1, J7.1, R2.2, U1.29
/FE_SCLK: J1.17, J2.3, J3.5, J4.5, J5.5, J7.5
/FE_SDA: J1.19, J2.7, J3.2, J4.2, J5.2, J7.2, R3.2, U1.30
/FE_SDIO: J1.18, J2.5, J3.4, J4.4, J5.4, J7.4
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.1, J1.4, J1.7, J1.10, J1.13, J1.15, J1.16, J1.27, J1.28, J1.29, J1.30, J1.31, J1.32, J1.33, J1.34, J1.35, J1.36, J1.37, J1.38, J1.39, J1.40, J1.SHLD, J2.10, J3.6, J3.7, J3.8, J3.9, J3.10, J3.12, J3.15, J3.17, J3.20, J3.21, J3.22, J3.23, J3.24, J3.26, J3.27, J3.28, J3.29, J3.SHLD, J4.6, J4.7, J4.8, J4.9, J4.10, J4.12, J4.15, J4.17, J4.20, J4.21, J4.22, J4.23, J4.24, J4.26, J4.27, J4.28, J4.29, J4.SHLD, J5.6, J5.7, J5.8, J5.9, J5.10, J5.12, J5.15, J5.17, J5.20, J5.21, J5.22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
unnamed: C2.1, J7.16, R6.2, R9.1
unnamed: C3.1, J8.3, L1.1, U2.2, U2.3
unnamed: C4.1, C5.1, C6.1, D1.1, J6.3, R4.1
unnamed: C4.2, R4.2, R5.1, U2.4
unnamed: C7.1, J5.16, R7.2, R11.1
unnamed: C8.1, J4.16, R12.2, R15.1
unnamed: C9.1, J3.16, R13.2, R17.1
unnamed: D1.2, L1.2, U2.6
unnamed: J3.18, R16.1
unnamed: J3.19, R16.2
unnamed: J4.18, R14.1
unnamed: J4.19, R14.2
unnamed: J5.18, R10.1
unnamed: J5.19, R10.2
unnamed: J7.18, R8.1
unnamed: J7.19, R8.2
unnamed: R1.2, U1.28

## Code that names these connections

File Firmware/XDMA/xdc/35t_50t/module_io.xdc:

#TS R4.1    FPGA Module R2
set_property -dict {PACKAGE_PIN U17 IOSTANDARD SSTL135} [get_ports led]
#JM1-96     JM1-95  LED         U17 [THIS IS BANK 14!]

set_property -dict {PACKAGE_PIN P6 IOSTANDARD LVCMOS33} [get_ports sync]
#JM1-94     JM1-93  SYNC        P6

set_property -dict {PACKAGE_PIN L3 IOSTANDARD LVCMOS33} [get_ports spi_sdio]
#JM2-31     JM2-32  PGA_SDIO    L3
set_property -dict {PACKAGE_PIN K2 IOSTANDARD LVCMOS33} [get_ports spi_sclk]
#JM2-33     JM2-34  PGA_SCLK    K2

set_property -dict {PACKAGE_PIN N1 IOSTANDARD LVCMOS33} [get_ports {pga_cs[3]}]
#JM2-43     JM2-44  PROBE_COMP  N1
set_property -dict {PACKAGE_PIN R3 IOSTANDARD LVCMOS33} [get_ports {pga_cs[2]}]
#JM2-53     JM2-54  PGA_CSn_3   R3
set_property -dict {PACKAGE_PIN K1 IOSTANDARD LVCMOS33} [get_ports {pga_cs[1]}]
#JM2-63     JM2-64  ATTEN_4     K1
set_property -dict {PACKAGE_PIN R6 IOSTANDARD LVCMOS33} [get_ports {pga_cs[0]}]
#JM2-68     JM2-67  ADC_PG      R6

set_property -dict {PACKAGE_PIN M1 IOSTANDARD LVCMOS33} [get_ports {atten[3]}]
#JM2-35     JM2-36  PGA_CSn_1   M1
set_property -dict {PACKAGE_PIN M5 IOSTANDARD LVCMOS33} [get_ports {atten[2]}]
#JM2-45     JM2-46  PGA_CSn_2   M5
set_property -dict {PACKAGE_PIN P1 IOSTANDARD LVCMOS33} [get_ports {atten[1]}]
#JM2-55     JM2-56  ATTEN_3     P1
set_property -dict {PACKAGE_PIN L4 IOSTANDARD LVCMOS33} [get_ports {atten[0]}]
#JM2-62     JM2-61  ADC_PD      L4

set_property -dict {PACKAGE_PIN N6 IOSTANDARD LVCMOS33} [get_ports {dc_cpl[3]}]
#JM2-37     JM2-38  ATTEN_1     N6
set_property -dict {PACKAGE_PIN M2 IOSTANDARD LVCMOS33} [get_ports {dc_cpl[2]}]
#JM2-47     JM2-48  ATTEN_2     M2
set_property -dict {PACKAGE_PIN T2 IOSTANDARD LVCMOS33} [get_ports {dc_cpl[1]}]
#JM2-57     JM2-58  DC_CPL_3    T2
set_property -dict {PACKAGE_PIN M6 IOSTANDARD LVCMOS33} [get_ports {dc_cpl[0]}]
#JM2-64     JM2-63  ADC_RSTn    M6

set_property -dict {PACKAGE_PIN P3 IOSTANDARD LVCMOS33} [get_ports {term[3]}]
#JM2-41     JM2-42  DC_CPL_1    P3
set_property -dict {PACKAGE_PIN N2 IOSTANDARD LVCMOS33} [get_ports {term[2]}]
#JM2-51     JM2-52  DC_CPL_2    N2
set_property -dict {PACKAGE_PIN P5 IOSTANDARD LVCMOS33} [get_ports {term[1]}]
#JM2-61     JM2-62  PGA_CSn_4   P5
set_property -dict {PACKAGE_PIN J4 IOSTANDARD LVCMOS33} [get_ports {term[0]}]
#JM2-66     JM2-65  ADC_CSn     J4

set_property -dict {PACKAGE_PIN K3 IOSTANDARD LVCMOS33} [get_ports probe_comp]
#JM2-65    JM2-66  DC_CPL_4    K3

set_property -dict {PACKAGE_PIN N3 IOSTANDARD LVCMOS33} [get_ports osc_oe]
#JM2-48     JM2-47  OSC_OE      N3

set_property -dict {PACKAGE_PIN M4 IOSTANDARD LVCMOS33} [get_ports acq_en]
#JM2-52     JM2-51  ACQ_EN      M4

set_property -dict {PACKAGE_PIN K6 IOSTANDARD LVCMOS33} [get_ports fe_en]
#JM2-54     JM2-53  FE_EN       K6

set_property -dict {PACKAGE_PIN N4 IOSTANDARD LVCMOS33} [get_ports i2c_sda]
#JM2-56     JM2-55  SDA         N4
set_property -dict {PACKAGE_PIN K5 IOSTANDARD LVCMOS33} [get_ports i2c_scl]
#JM2-58     JM2-57  SCL         K5

set_property -dict {PACKAGE_PIN J5 IOSTANDARD LVCMOS33} [get_ports adc_cs]
#JM2-46     JM2-45  FE_PG       J5

###############################################################################
# SPI
###############################################################################
set_property PACKAGE_PIN K16 [get_ports qspi_d0]
set_property PACKAGE_PIN L17 [get_ports qspi_d1]
set_property PACKAGE_PIN J15 [get_ports qspi_d2]
set_property PACKAGE_PIN J16 [get_ports qspi_d3]

set_property IOSTANDARD SSTL135 [get_ports qspi_d0]
set_property IOSTANDARD SSTL135 [get_ports qspi_d1]
set_property IOSTANDARD SSTL135 [get_ports qspi_d2]
set_property IOSTANDARD SSTL135 [get_ports qspi_d3]

set_property PACKAGE_PIN L15 [get_ports qspi_cs]
set_property IOSTANDARD SSTL135 [get_ports qspi_cs]

set_property INTERNAL_VREF 0.675 [get_iobanks 14]

#############################################################################################################
##ADC Differential I/O
#############################################################################################################

set_property -dict {PACKAGE_PIN R2 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports adc_lclk_p]
set_property -dict {PACKAGE_PIN R1 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports adc_lclk_n]

set_property -dict {PACKAGE_PIN U2 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports adc_fclk_p]
set_property -dict {PACKAGE_PIN U1 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports adc_fclk_n]

##NOT INVERTED [7:0]
set_property -dict {PACKAGE_PIN U4 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_p[0]}]
set_property -dict {PACKAGE_PIN V4 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_n[0]}]

##NOT INVERTED [15:8]
set_property -dict {PACKAGE_PIN V3 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_p[1]}]
set_property -dict {PACKAGE_PIN V2 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_n[1]}]

##INVERTED [23:16]
set_property -dict {PACKAGE_PIN U7 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_p[2]}]
set_property -dict {PACKAGE_PIN V6 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_n[2]}]

##INVERTED [31:24]
set_property -dict {PACKAGE_PIN V8 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_p[3]}]
set_property -dict {PACKAGE_PIN V7 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_n[3]}]

##NOT INVERTED [39:32]
set_property -dict {PACKAGE_PIN R5 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_p[4]}]
set_property -dict {PACKAGE_PIN T5 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_n[4]}]

##INVERTED [47:40]
set_property -dict {PACKAGE_PIN T4 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_p[5]}]
set_property -dict {PACKAGE_PIN T3 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_n[5]}]

##INVERTED [55:48]
set_property -dict {PACKAGE_PIN U6 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_p[6]}]
set_property -dict {PACKAGE_PIN U5 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_n[6]}]

##INVERTED [63:56]
set_property -dict {PACKAGE_PIN R7 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_p[7]}]
set_property -dict {PACKAGE_PIN T7 IOSTANDARD LVDS_25 DIFF_TERM 0} [get_ports {adc_data_n[7]}]

############################################################################################################
# PCIe x4
############################################################################################################

# PCIe lane 0 / GTP 3
#set_property LOC GTPE2_CHANNEL_X0Y3 [get_cells {design_1_i/PCIe/xdma_0/inst/design_1_xdma_0_0_pcie2_to_pcie3_wrapper_i/pcie2_ip_i/inst/inst/gt_top_i/pipe_wrapper_i/pipe_lane[0].gt_wrapper_i/gtp_channel.gtpe2_channel_i}]
set_property PACKAGE_PIN G3 [get_ports {pcie_mgt_rxn[0]}]
set_property PACKAGE_PIN G4 [get_ports {pcie_mgt_rxp[0]}]
set_property PACKAGE_PIN B1 [get_ports {pcie_mgt_txn[0]}]
set_property PACKAGE_PIN B2 [get_ports {pcie_mgt_txp[0]}]

# PCIe lane 1 / GTP 2
#set_property LOC GTPE2_CHANNEL_X0Y2 [get_cells {design_1_i/PCIe/xdma_0/inst/design_1_xdma_0_0_pcie2_to_pcie3_wrapper_i/pcie2_ip_i/inst/inst/gt_top_i/pipe_wrapper_i/pipe_lane[1].gt_wrapper_i/gtp_channel.gtpe2_channel_i}]
set_property PACKAGE_PIN C3 [get_ports {pcie_mgt_rxn[1]}]
set_property PACKAGE_PIN C4 [get_ports {pcie_mgt_rxp[1]}]
set_property PACKAGE_PIN D1 [get_ports {pcie_mgt_txn[1]}]
set_property PACKAGE_PIN D2 [get_ports {pcie_mgt_txp[1]}]

# PCIe lane 2 / GTP 1
#set_property LOC GTPE2_CHANNEL_X0Y1 [get_cells {design_1_i/PCIe/xdma_0/inst/design_1_xdma_0_0_pcie2_to_pcie3_wrapper_i/pcie2_ip_i/inst/inst/gt_top_i/pipe_wrapper_i/pipe_lane[2].gt_wrapper_i/gtp_channel.gtpe2_channel_i}]
set_property PACKAGE_PIN A3 [get_ports {pcie_mgt_rxn[2]}]
set_property PACKAGE_PIN A4 [get_ports {pcie_mgt_rxp[2]}]
set_property PACKAGE_PIN F1 [get_ports {pcie_mgt_txn[2]}]
set_property PACKAGE_PIN F2 [get_ports {pcie_mgt_txp[2]}]

# PCIe lane 3 / GTP 0
#set_property LOC GTPE2_CHANNEL_X0Y0 [get_cells {design_1_i/PCIe/xdma_0/inst/design_1_xdma_0_0_pcie2_to_pcie3_wrapper_i/pcie2_ip_i/inst/inst/gt_top_i/pipe_wrapper_i/pipe_lane[3].gt_wrapper_i/gtp_channel.gtpe2_channel_i}]
set_property PACKAGE_PIN E3 [get_ports {pcie_mgt_rxn[3]}]
set_property PACKAGE_PIN E4 [get_ports {pcie_mgt_rxp[3]}]
set_property PACKAGE_PIN H1 [get_ports {pcie_mgt_txn[3]}]
set_property PACKAGE_PIN H2 [get_ports {pcie_mgt_txp[3]}]

# PCIe refclock
set_property PACKAGE_PIN B6 [get_ports {pcie_clk_p[0]}]
set_property PACKAGE_PIN B5 [get_ports {pcie_clk_n[0]}]

# PCIe PERSTn
set_property -dict {PACKAGE_PIN L2 IOSTANDARD LVCMOS33} [get_ports pcie_perstn]

############################################################################################################
# Clock
############################################################################################################
set_property -dict {PACKAGE_PIN P4 IOSTANDARD LVCMOS33} [get_ports ext_clk]

File DSO_Firmware/Serial_Controller/Serial_Controller.ucf:

NET "clk" TNM_NET = clk;
TIMESPEC TS_clk = PERIOD "clk" 32 MHz HIGH 50%;

NET "clk" LOC = P87 | IOSTANDARD = LVTTL;

NET "ft2_data<0>" LOC = P104 | IOSTANDARD = LVTTL;
NET "ft2_data<1>" LOC = P102 | IOSTANDARD = LVTTL;
NET "ft2_data<2>" LOC = P101 | IOSTANDARD = LVTTL;
NET "ft2_data<3>" LOC = P100 | IOSTANDARD = LVTTL;
NET "ft2_data<4>" LOC = P99 | IOSTANDARD = LVTTL;
NET "ft2_data<5>" LOC = P98 | IOSTANDARD = LVTTL;
NET "ft2_data<6>" LOC = P97 | IOSTANDARD = LVTTL;
NET "ft2_data<7>" LOC = P95 | IOSTANDARD = LVTTL;

NET "ft2_rxf_n" LOC = P94 | IOSTANDARD = LVTTL;
NET "ft2_txe_n" LOC = P93 | IOSTANDARD = LVTTL;

NET "ft2_rd_n" LOC = P92 | IOSTANDARD = LVTTL;
NET "ft2_wr_n" LOC = P88 | IOSTANDARD = LVTTL;

NET "fe_sda" LOC = P84 | IOSTANDARD = LVTTL;
NET "fe_scl" LOC = P85 | IOSTANDARD = LVTTL;

NET "fe_sdo" LOC = P82 | IOSTANDARD = LVTTL;
NET "fe_sclk" LOC = P81 | IOSTANDARD = LVTTL;
NET "fe_cs<0>" LOC = P115 | IOSTANDARD = LVTTL;
NET "fe_cs<1>" LOC = P114 | IOSTANDARD = LVTTL;
NET "fe_cs<2>" LOC = P112 | IOSTANDARD = LVTTL;
NET "fe_cs<3>" LOC = P111 | IOSTANDARD = LVTTL;

NET "adc_pll_sdo" LOC = P79 | IOSTANDARD = LVTTL;
NET "adc_pll_sclk" LOC = P78 | IOSTANDARD = LVTTL;
NET "adc_pll_cs<0>" LOC = P80 | IOSTANDARD = LVTTL;
NET "adc_pll_cs<1>" LOC = P83 | IOSTANDARD = LVTTL;

NET "adc_rst_n" LOC = P75 | IOSTANDARD = LVTTL;
NET "adc_pd" LOC = P74 | IOSTANDARD = LVTTL;

//NET "led<0>" LOC = P35 | IOSTANDARD = LVTTL;
//NET "led<1>" LOC = P34 | IOSTANDARD = LVTTL;
//NET "led<2>" LOC = P33 | IOSTANDARD = LVTTL;
//NET "led<3>" LOC = P32 | IOSTANDARD = LVTTL;

File Hardware/KiCad/HMCAD1520_Impedence_Checker/HMCAD1520_Impedence_Tester/HMCAD1520_Impedence_Tester.ino:

#define SEL0 17
#define SEL1 16
#define SEL2 15

void setup() {
  Serial.begin(9600);
  pinMode(SEL0, OUTPUT);
  pinMode(SEL1, OUTPUT);
  pinMode(SEL2, OUTPUT);
  digitalWrite(SEL0, LOW);
  digitalWrite(SEL1, LOW);
  digitalWrite(SEL2, LOW);
}

void loop() {
  while (Serial.available() > 0) {
    char input = Serial.read();
    if (input == '0'){  //AVDD
      digitalWrite(SEL0, LOW);
      digitalWrite(SEL1, LOW);
      digitalWrite(SEL2, LOW);
    }
    else if (input == '1'){ //AVDD2
      digitalWrite(SEL0, LOW);
      digitalWrite(SEL1, LOW);
      digitalWrite(SEL2, HIGH);
    }
    else if (input == '2'){ //DVDD
      digitalWrite(SEL0, HIGH);
      digitalWrite(SEL1, LOW);
      digitalWrite(SEL2, LOW);
    }
    else if (input == '3'){ //OVDD
      digitalWrite(SEL0, HIGH);
      digitalWrite(SEL1, HIGH);
      digitalWrite(SEL2, LOW);
    }
    Serial.print(input);
  }
}

## Commit log (part)

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2024-03-11 Added STEP File for TS PCIe Bracket
2024-05-07 Added 50T Custom Module Gateware
2024-05-11 Beta 2 gateware release
2024-05-11 Added bitstream outputs
2024-05-15 azonenberg kernel backport fixes
2024-05-15 cherry-pick the changes properly (hopefully)
2024-05-15 more cherry-festivities
2024-05-15 more cherry-festivities - fixed
2024-06-17 Updated gitmodules
2024-06-17 Updated gitmodules correctly
2024-06-17 Updated gitmodules, for real this time
2024-06-25 Removed output files from tools directory
2024-06-25 Added executable flag for .sh files
2024-07-10 Updated ngscopeclient submodule
2024-07-21 Added Rework Instructions for Beta 2
2024-08-06 Auto stash before checking out "origin/master"
    Marked buffer output resistor on rework diagram
2024-08-12 Added Rev.5 Front End Test Board (WIP)
2024-08-16 Add LiteX setup guide to docs. Update Litex firmware submodule
2024-08-17 Update LiteX.md links
    Update libtslitex repo link to point to main EEvengers repo.
2024-08-23 Rev.5 Front End Test Board WIP
2024-09-11 Added DDR3 Wraparound and Wraparound_Overflow Flags
2024-09-11 Added s2mm_halt_cmplt signal to datamover reg
2024-09-12 Added wraparounds and halt_cmplt signal to 100t
2024-09-12 Added wraparounds and halt_cmplt signal to 50t
2024-09-13 Added bitstreams
2024-09-24 Finished Rev 5 FE Test Boards, Fixtures WIP
2024-09-25 Finished HMCAD1520 Impedance Checker
2024-10-14 Update LiteX setup guide
2024-10-15 Rev5 WIP, schematic overhaul
2024-10-18 Nuke Gitmodules
2024-10-18 Moved XDMA to Archive Repo, Added Build Scripts
2024-10-18 Added flashing script for prebuilt bitstreams
2024-10-18 Modified scripts to not use home dir
2024-10-18 Updated Gitignore for Gateware
2024-10-19 Added script to build and flash ts litex gateware
2024-10-19 Updated script to source Vivado
2024-10-19 Changed --load to --flash to flash qspi
2024-10-30 Changed scripts to pull repo if already cloned
2024-11-09 Added Firmware For Test Boards
2024-11-09 Rev5 FE Test Board V2 Sent to Fab
2024-11-25 Kicad Import of Rev 5, still needs polishing
2024-11-26 Altium Param Import with Script
2024-12-10 Added WIP Mech Model and Interposer
    Also reworked rev5 power tree
2024-12-12 Updated mech model schematic to match pcb
2024-12-14 Schematic WIP
2024-12-15 Sent Mech Models Out to Fab
2024-12-16 Added Noise Rework Step 1 Pictures
2024-12-16 Added result for noise rework 2
2024-12-16 Added second noise rework.md
2024-12-16 Added photos for Beta 2 noise rework 3
2024-12-17 Fix malformed .kicad_pcb files
    The STEP exporter was not handling that well.
2024-12-17 Set mech model pcb thickness as 1.6mm
    To match the actual Thunderscope stackup thickness.
2024-12-17 Create Kicad end caps
    They don't match the assembly yet.
2024-12-18 Refactored Schematic
2024-12-19 Schematic Rapidly Approaching Done
    Still have to clear some new ERCs from the refactor
2024-12-19 Removed old license
2024-12-22 Added Arduino Control Script
    Fixed it to talk to the DPOT correctly
2025-01-24 Added Front End Cap
2025-01-27 Added Back End Cap, End Caps Sent to Fab
2025-02-04 Updated FreeCAD Mechanical Assembly
2025-02-15 Updated scripts to use ota_support branch and our fork of openFPGAloader
2025-02-16 Moved Fan Board Edge Down 0.9mm
2025-02-17 Moved Fan Right 0.5mm, Increased Text Size
2025-02-22 Interposer Board WIP
2025-02-22 Interposer Mech Changes
    Moved adaptor back 0.5mm to align with board edge. Changed mounting holes to M2, and added exposed copper on edges.
2025-02-22 Changed Mech Model to use M2 Mounting Hardware
2025-02-27 IOCrest Interposer WIP
    DXF Output will be used to laser cut for test fit
2025-03-02 IOCrest Interposer WIP
2025-03-02 JoneyTech Interposer Diff Pairs Skew Matched
2025-03-05 Rev 5 WIP
    Added probe comp variants
2025-03-06 Finished all new schematic TODOs
2025-03-07 Added Heatsink and Missing 3D Models
2025-03-10 Placement WIP
2025-03-13 Got multi-channel routing working
    Needed to change refdes on front end channel components
2025-03-14 Placed Front End Support Circuits
2025-03-18 Fixed Net Swaps
    On Sync_REn & SYNC_DE as well as MGT_CLK1
2025-03-21 Routed FE Support Components
2025-03-21 Finished Routing FE Voltage Regs
2025-03-22 Misc WIP
    Changed ADC decoupling, improved acq reg placement, etc.
2025-03-23 Finished Routing ACQ regulators
2025-03-23 Playing with Custom Design Rules
2025-03-25 LVDS Routing WIP
    Also placed PCIe stuffing options
2025-03-25 Started diff pair routing
    I miss Altium :(
2025-03-25 Started routing all other diff pairs
    I miss Altium :(
2025-03-27 Added first pass interactive delay tuner
2025-03-27 Got delay tuner to write to rules file
2025-03-29 Diff pair cleanup and rerouting
2025-03-29 Placed most of the FPGA decoupling
2025-03-29 Placed and Routed QSPI
    All decoupling and FPGA support components placed
2025-04-01 Final signal routing WIP
2025-04-04 Finished all signal routing
    PWR, GND and Length Tuning remains
2025-04-04 Power planes WIP
2025-04-06 Finished ACQ power planes
    Working on GND planes now
2025-04-07 Increased trace spacing where possible
2025-04-07 Reversed Channel Order
    In channel blocks, net labels, and reference designators
2025-04-07 Added more test points
    Everything on Bank 14 covered except HWIDs, VARIENT, and PUDC
2025-04-08 Added test points on all shunts that didn't have them
2025-04-10 Via stitching in progress
2025-04-11 Delay Matched PGA Outputs
2025-04-11 Moved CLK25 to P side of MRCC pair
    Swapped with LED_R
2025-04-11 ADC LVDS Pairs Delay and Skew Matched
2025-04-12 Via Stitching WIP
    Unmatched PGA Diff pairs, will need to redo that
2025-04-14 Final Polish WIP
2025-04-15 DRC Clean
    Just need to double check delay matching and look over bottom layer copper before release to fab
2025-04-15 Final review before fab
2025-04-16 Interposer out to fab
2025-04-16 JoneyTech Interposer out to fab
2025-04-22 Added post campaign update 2
2025-04-28 Updated Interposer Boards
    Used PCBway's trace/space on diff pairs, fixed bottom soldermask on edge connectors, and board outline tweaks
2025-04-29 Finished Test Fixture Board, added M.2 GND Cutouts
2025-05-14 Made Docs Structure + Box Build WIP
2025-05-15 TS-USB4 Box Build WIP
2025-05-16 Deploying to gh-pages from @ EEVengers/ThunderScope@8e3991238495610a4c5105715ed6616d842ff4fd 🚀
2025-05-19 Added instructions for Step 6
2025-05-19 Made sourcing info for endcaps into notes
2025-05-20 Swapped pinout of fan pads
2025-05-23 Calibration docs WIP
2025-05-23 Added attenuator HF cal section
2025-06-16 Updated build scripts
2025-07-10 Moved to Kicad 9.0.3, Fixed #304
2025-07-10 Fixed #305
2025-07-10 Fixed #305, Moved TP36
    Added 10KOhm R86 in parallel with C77 in SCH. Updated PCB to add the extra 0402 - had to move TP36
2025-07-12 New +VUSB Buck WIP
    Just need to add some poly pours
2025-07-16 Finished FE Support Component Changes from #333, #334
2025-07-16 Added Charge Pump Output Filter as per #335
2025-07-17 Added extra caps to boost reg - closes #336
2025-07-18 Swapped Relay PNs, Implements #337
    Also removed ground pour from CH1
2025-07-18 Changed Relay Caps to 22uF 0805 as per #338
2025-07-19 Schematic changes for #339
2025-07-21 Finished layout for #339
    Also added new attenuator gnd cutouts with fewer cutouts on CH3 and no cutouts on CH4
2025-07-22 Schematic Changes for #340
2025-07-22 Schematic Changes for #341 and #342
2025-07-22 Changed opamp footprint for #340
    Will change the footprint in the bias circuit in a later commit for #344
2025-07-26 Layout roughed in for #340
2025-07-27 Cloned new #340 front end layout across channels
    Bottom side decoupling WIP
2025-07-28 Finished layout for #340, #341, #342
2025-07-29 Changed opamp package and did layout for #344
2025-07-30 Added cutouts for #347
2025-07-31 Finished layout changes for #346
2025-08-01 Moved test points per #349
2025-08-02 Added updated schematic PDF
2025-08-04 Boost converter changes for #353 & #355
2025-08-04 Moved DONE via as per #357
2025-08-04 Moved 1V8 inductor as per #358
2025-08-04 Added 1uF on output of relay filters as per #356
2025-08-04 Moved planes as per #359
2025-08-11 Bed of Nails Adaptor Sent to Fab, Closes #362
2025-08-19 Initial Commit of Windows Install Script
2025-08-19 Script now runs driver install on next boot
2025-08-19 Fixed comment
2025-08-19 Use IDs and specify source for Winget
2025-08-19 Updated ngscopeclient portable
2025-08-19 Script now makes a recent.yml entry
2025-08-20 Windows getting started guide WIP
2025-08-20 Deploying to gh-pages from @ EEVengers/ThunderScope@a5aad7cff7e73e21222b36bbab28ca4a329a8999 🚀
2025-09-02 Corrected DAC PN to resolve issue #373
2025-09-04 MUXBOARD added
2025-09-15 Test fixture boards out to fab
2025-09-20 Changed DAC PN, Closes #373
2025-09-20 5.2 Initial Commit, Changed Caps for #386
2025-09-20 Changed R1022 for #387
2025-09-20 Changed R1021 for #388
2025-09-21 Routed Attenuator for #389 and cutouts for #385
2025-09-22 Rev 5.2 out to fab
2025-11-18 Rev5.3 Initial Commit
    Upped rev number on SCH and PCB
2025-11-18 Changed C1021 to 4pF, closes #412
2025-11-18 Changed C1011 to 3pF, closes #409
2025-11-19 Changed C1012 to thin film part for #408
2025-11-19 Embedded 3D Models for #413
2026-01-03 Changed C1021 to 3pF, closes #412
2026-01-03 Changed R1021 & C1058 per #423
2026-01-03 Changed C65 to 100nF, closes #422
2026-01-03 Schematic Changes for #421
    Also changed sch note re: pcie coupling caps
2026-01-03 PCB Changes for #421
2026-01-04 Removed Clock Test Ports, Closing #406
2026-01-04 Added & Embedded Remaining 3D models, Closes #413
2026-01-04 Added CE & UKCA Markings, Closes #405
2026-01-08 PCB Changes for #424
2026-01-10 Added PDF Schematic
2026-01-14 Polish Round 1
    Cleaned up diff pairs in relation to ground stitching, added cutouts under ADC driver QFNs, Moved bottom silkscreen to not overlap with the new ADC driver 10uF decoupling caps
2026-01-14 Readded thermal reliefs on pads from Rev 5.2
    Everything got reset to direct connect so I used a script to find all the footprints I put reliefs on last rev
2026-01-14 Added thermal reliefs to ADC driver VCM cap
2026-01-15 Added Silkscreen Cert Markings to Footprint Library
2026-01-15 Cleaned up unused layers
    Some footprints had assembly outline on random user layers
2026-01-16 Changed Text Sizes on Assembly Layer
    Improves Assembly Drawing Legibility
2026-01-16 Bottom Assembly Layer Polish
    Also added note to not break tabs on both assembly layers and fab notes
2026-01-16 Added Stackup and Impedance Tables to Fab Notes
2026-01-17 DNP'd Keystone TPs and Excluded PCIe Bracket and Shield LID from BOM
2026-01-17 Changed C100 to 18pF from 12pF for BOM consolidation
2026-01-17 Added DRC Report
2026-01-19 Incremented HWID from 1 to 2, closes #425
2026-01-19 Release Jobset WIP
2026-01-19 Added VARIANT Project Variable
2026-01-19 Removed old schematic notes 2
2026-01-19 Fabrication Outputs for Final Review
2026-01-21 Updated Description Field for Every Symbol
2026-01-21 Added Substitutions Policy Field
2026-01-21 Changed 10k,4.7k,280k resistors MPNs to RC0402FR series
2026-01-21 Set Fabrication Attributes on all Footprints
2026-01-21 Updated PCB
2026-01-21 Set "Not in Schematic" Flag for logos, tab holes, and slots
    This should prevent LVS from yelling at us
2026-01-21 Updated list of DRC exclusions
    Only ignored tests are now silkscreen related
2026-01-21 Update PCB
    Just change of footprint filters for heatsink
2026-01-21 Removed Outputs in Main Project Directory
2026-01-22 Jobset and Output Structure Changes from Review
    Merged top and bottom position files
    Disabled gerber job file generation
    Directory Changes
2026-01-22 Added TS-PCIe Variant Outputs
    Note only timestamps have changed on ERC, DRC, and PCB outputs
2026-01-22 Updated TS-PCIe Top Render
    Does not include heatsink and has 3d model for ECS_TXO-2016
2026-01-22 Updated footprint for ECS_TXO-2016
2026-01-23 Added Board Characteristics Table on Fab Notes
    This also specifies ENIG copper finish as that wasn't mentioned elsewhere
2026-01-23 Allowed for ECOs to sub KOA Speer Resistors
2026-01-23 Added Consigned Field to BOMs
2026-01-23 Deploying to gh-pages from @ EEVengers/ThunderScope@d05f88e9fbadae5f9c9c3499ac05a1bcd2704247 🚀
2026-01-23 Corrected MPN for Resistor Array
